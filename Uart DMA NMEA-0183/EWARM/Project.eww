<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Uart_DMA_NMEA_0183.ewp</path>
  </project>
  <batchBuild />
</workspace>
